FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_append_ros = "file://ros-splash-img.h;outsuffic=ros"
ALTERNATIVE_PRIORITY_psplash-ros[psplash] = "20"
