require python-catkin-pkg.inc

SRC_URI[md5sum] = "de01650bbec245d53f72682ed7ab13e5"
SRC_URI[sha256sum] = "434b25fcfec016d10778297c845365de2be6d305b7eab91195d08ceb5b19d354"

inherit distutils
