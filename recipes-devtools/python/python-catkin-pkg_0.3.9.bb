require python-catkin-pkg.inc

SRC_URI[md5sum] = "39405b11aba691b7a9660a1ceaf25f84"
SRC_URI[sha256sum] = "ecc4fd6b6c7cebc0d9a38fc38dc0e270cc4e684a6c874a006b2834a98bf5590c"

inherit setuptools
inherit distutils
