require python-rosdep.inc

SRC_URI[md5sum] = "28a18dd497599010bb01107f832e7831"
SRC_URI[sha256sum] = "8185ee4114f860140672c9f311e11b0eb5b2dcfbb6eb524bb7ff03b6ceb887ae"

inherit setuptools
