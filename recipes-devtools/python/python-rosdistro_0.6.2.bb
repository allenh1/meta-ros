require python-rosdistro.inc

SRC_URI[md5sum] = "5ef1af890d0fc92c6920c4c86ef498cd"
SRC_URI[sha256sum] = "834776e7419465b23080b099ddb3b981fbe8623442ed2b446989f3fa998fb178"

inherit setuptools
