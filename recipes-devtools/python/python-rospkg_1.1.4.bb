require python-rospkg.inc

SRC_URI[md5sum] = "103c57a455fb01b5018e01c94ee598aa"
SRC_URI[sha256sum] = "9d93bbf646c3db7e5ffd9814a879fe76cf45d2aa0a0bb210f44e807ea41a4c70"

inherit setuptools
